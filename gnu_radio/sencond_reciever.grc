options:
  parameters:
    author: nivkarasenty
    generate_options: qt_gui
    id: Reciever
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: RX_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '50'
    value: '50'
  states: {}
- name: RX_gain_0
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '50'
    value: '50'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: d
  id: variable
  parameters:
    value: '0.062'
  states: {}
- name: host_address
  id: variable
  parameters:
    value: '"172.20.10.7"'
  states: {}
- name: moving_average
  id: variable
  parameters:
    value: '512'
  states: {}
- name: port
  id: variable
  parameters:
    value: '"5005"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: send_every
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: tone_freq
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: AoA_mod_phase_to_angle_0
  id: AoA_mod_phase_to_angle
  parameters:
    center_freq: center_freq
    d: d
    samp_rate: samp_rate/10
    tone_freq: tone_freq
  states: {}
- name: AoA_mod_phase_to_angle_0_0
  id: AoA_mod_phase_to_angle
  parameters:
    center_freq: center_freq
    d: d
    samp_rate: samp_rate/10
    tone_freq: tone_freq
  states: {}
- name: AoA_mod_send_to_server_0
  id: AoA_mod_send_to_server
  parameters:
    host: host_address
    port: port
    send_every: send_every
    station_id: RX2
  states: {}
- name: AoA_mod_send_to_server_0_0
  id: AoA_mod_send_to_server
  parameters:
    host: host_address
    port: port
    send_every: send_every
    station_id: RX1
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_0_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: int(moving_average)
    max_iter: '4000'
    scale: 1/moving_average
    type: complex
  states: {}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: int(moving_average)
    max_iter: '4000'
    scale: 1/moving_average
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: tone_freq
    decim: '10'
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, 10e3, 1e3)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: tone_freq
    decim: '10'
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, 10e3, 1e3)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: tone_freq
    decim: '10'
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, 10e3, 1e3)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: tone_freq
    decim: '10'
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, 10e3, 1e3)
    type: ccc
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/10
    fc: '0'
    fftsize: '1024'
    name: '"input 1"'
    type: complex
  states: {}
- name: qtgui_sink_x_1_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/10
    fc: '0'
    fftsize: '1024'
    name: '"input 1"'
    type: complex
  states: {}
- name: qtgui_sink_x_2
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/10
    fc: '0'
    fftsize: '1024'
    name: '"input 2"'
    type: complex
  states: {}
- name: qtgui_sink_x_2_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/10
    fc: '0'
    fftsize: '1024'
    name: '"input 2"'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: '"RX2"'
    center_freq0: center_freq
    center_freq1: center_freq
    dev_addr: 'serial: 34D049F'
    gain0: RX_gain
    gain1: RX_gain
    nchan: '2'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: '"RX2"'
    center_freq0: center_freq
    center_freq1: center_freq
    dev_addr: 'serial: 34D0497'
    gain0: RX_gain
    gain1: RX_gain
    nchan: '2'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [AoA_mod_phase_to_angle_0, '0', AoA_mod_send_to_server_0, '0']
- [AoA_mod_phase_to_angle_0_0, '0', AoA_mod_send_to_server_0_0, '0']
- [blocks_complex_to_arg_0, '0', AoA_mod_phase_to_angle_0, '0']
- [blocks_complex_to_arg_0_0, '0', AoA_mod_phase_to_angle_0_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '1']
- [blocks_conjugate_cc_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_moving_average_xx_0, '0', blocks_complex_to_arg_0, '0']
- [blocks_moving_average_xx_0_0, '0', blocks_complex_to_arg_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_moving_average_xx_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_multiply_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_sink_x_1, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', blocks_conjugate_cc_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', qtgui_sink_x_2, '0']
- [freq_xlating_fir_filter_xxx_0_0_0, '0', blocks_conjugate_cc_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0, '0', qtgui_sink_x_2_0, '0']
- [freq_xlating_fir_filter_xxx_0_1, '0', blocks_multiply_xx_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_1, '0', qtgui_sink_x_1_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [uhd_usrp_source_0, '1', freq_xlating_fir_filter_xxx_0_0, '0']
- [uhd_usrp_source_0_0, '0', freq_xlating_fir_filter_xxx_0_1, '0']
- [uhd_usrp_source_0_0, '1', freq_xlating_fir_filter_xxx_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
