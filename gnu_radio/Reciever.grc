options:
  parameters:
    author: nivkarasenty
    generate_options: qt_gui
    id: Reciever
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: RX_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '20'
    value: '0'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: tone_freq
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: variable_2
  id: variable
  parameters:
    value: '0'
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    ant1: '"RX2"'
    center_freq0: center_freq
    center_freq1: center_freq
    gain0: RX_gain
    gain1: RX_gain
    nchan: '2'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '0']
- [uhd_usrp_source_0, '0', blocks_conjugate_cc_0, '0']
- [uhd_usrp_source_0, '1', blocks_multiply_xx_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
